# Repository eddyem/STM8_samples

File Readme.md:

Some my projects based on STM8
==============================

Developed for SDCC compiler. [Here](https://github.com/gicking/STM8_headers) you can find some more 
heades under MIT license.

## Directory listing

- 1-wire  
1-wire for DS18x20 based on timer and interrupts.
- 220controlled_socket  
Simple two-channel power socket manager with current measurement at one channel.
- blinky  
Just blink LED.
- client-term-8bit  
Simplest terminal client.
- distance_meter  
Ultrasonic distance meter.
- DRUM  
(not even started at all) Approach to toy drum.
- led  
Work with 4-digit LED indicator.
- LEDS_BT  
Bluetooth-management 7/8-channel LED "stars".
- microdrill  
Microdrill management (pre-pre-alpha).
- Noice_generator  
Waveform generator.
- si7005  
Work with SI7005 sensor.
- si7005_softi2c  
`si7005` with soft I2C.
- SNIPPETS  
Some snippets.
- stepper, stepper_independent, stepper_independent_bin  
Different approaches to implementation of stepper motor control.
- stepper_ULN2003  
Unipolar stepper control.
- stm8l.h, stm8s.h (all the same) - header file for all projects.
- Thermostat  
Schematic of STM8-based chinese thermostat.
- uart_lcd5110  
Work with Nokia5110 LCD with PCD8544 controller.
- uart_sample  
USART snippet for futher use.
- uart_SPI  
USART/SPI gateway.
- voltmeters  
3-,4- and 5-digit chinese "voltmeters" based on STM8: schematic and some my code for them.
- zakwire  
Use 3-digit "voltmeter" as display for Zakwire temperature sensor.

## KiCad design LEDS_BT/kicad/8leds.kicad_pcb

File LEDS_BT/Readme:

Setup "bluetooth control 8-lamp", connect STM8S103F2 to bluetooth HC-06.
Manage up to 8 LEDs controlled by bluetooth module HC-06

Board: 2 copper layers, 65.0 x 41.5 mm, 40 parts (1 on the bottom side), 29 nets.

Parts:
C1, C2: 0.1; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: SS14; D_SMA_Handsoldering
J1, J3, J4, J5, J6, J7, J8, J9, J10: Conn2; solderpad2
J2: Bluetooth; PinSocket_1x04_P2.54mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: IRLML2502; SOT-23_Handsoldering
R1, R3, R5, R7, R9, R11, R13, R15: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R4, R6, R8, R10, R12, R14, R16: 510; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: LM1117-5.0; SOT-223-3_TabPin2
U2: STM8S103devbrd

Connections:
+5V: C2.2, C3.1, J2.4, U1.2, U2.8
+12V: C1.2, D1.1, J1.2, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, U1.3
/MOSFET/ChX: R1.1, R2.2, U2.20
/Rxd: J2.1, U2.2
/Txd: J2.2, U2.3
/sheet5DFF4C24/ChX: R15.1, R16.2, U2.13
/sheet5DFF31D8/ChX: R3.1, R4.2, U2.19
/sheet5DFF38E9/ChX: R9.1, R10.2, U2.16
/sheet5DFF366E/ChX: R7.1, R8.2, U2.17
/sheet5DFF447B/ChX: R13.1, R14.2, U2.14
/sheet5DFF3431/ChX: R5.1, R6.2, U2.18
/sheet5DFF4250/ChX: R11.1, R12.2, U2.15
GND: C1.1, C2.1, C3.2, D1.2, J1.1, J2.3, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, R1.2, R3.2, R5.2, R7.2, R9.2, R11.2, R13.2, R15.2, U1.1, U2.7
unnamed: J3.2, Q1.3
unnamed: J4.2, Q2.3
unnamed: J5.2, Q3.3
unnamed: J6.2, Q4.3
unnamed: J7.2, Q5.3
unnamed: J8.2, Q6.3
unnamed: J9.2, Q7.3
unnamed: J10.2, Q8.3
unnamed: Q1.1, R2.1
unnamed: Q2.1, R4.1
unnamed: Q3.1, R6.1
unnamed: Q4.1, R8.1
unnamed: Q5.1, R10.1
unnamed: Q6.1, R12.1
unnamed: Q7.1, R14.1
unnamed: Q8.1, R16.1

## KiCad design microdrill/schematics_new/MCU_module.kicad_pcb

File microdrill/README:

Algorithm

1. Main functionality - footswitch

By pressing footswitch you move drill down. Speed setup produced
by variable resistor on tray's control. Pulling footswitch
up returns drill into its previous position. If you press down the
footswitch when drill haven't reach its starting position, it moves down
again and returns back on next pulling up.

If drill motor was off, pressing footswitch will also turn it on.

If you pull down the footswitch when one of the tray buttons pressed, the
tray will move up or down.

2. Tray buttons

2.1. Left button (BTN1) 
	- press it and rotate potentiometer to change drill speed
	- press both buttons to stop the drill
	- press footswitch when it pressed to move tray

2.2. Right button (BTN2)
	- press it and rotate potentiometer to change stepper speed
	- press both buttons to stop the drill
	- press footswitch when it pressed to move tray

2.3. Simultaneous pressing of both buttons will stop drill motor

The stepper's speed changes depending on current in drill motor. If it is too big,
the stepper paused until current will fall. The idle motor motion (upwards) done
on biggest speed.

To change the drill bit just press one of the tray buttons and push down the
footswitch. The tray will go up. To move it down press tray button and footswitch
again.

Parts:
+5V1: CONN_1; 1PIN
BTN1, BTN2: CONN_1; 1PIN
C1: 0.1u; C_0603_1608Metric_Pad0.84x1.00mm_HandSolder
C2, C4: 0.1u; C_0805_2012Metric_Pad1.15x1.50mm_HandSolder
C3: 1u; C_0805_2012Metric_Pad1.15x1.50mm_HandSolder
DA1, DA2, DA3: L9110; SOIC-8_3.9x4.9mm_P1.27mm
DOWN1: CONN_1; 1PIN
GND1: CONN_1; 1PIN
INPUT0, INPUT1: CONN_1; 1PIN
J1: USART; PinSocket_1x04_P2.54mm_Horizontal
J2: SWIM; PinSocket_1x03_P2.54mm_Horizontal
K1: POWER; 3PIN_Pwr
LED0, LED1, LED2: CONN_1; 1PIN
P1: Drill; 2PIN_Pwr
P2: DrillSW; 2PIN
P3: Stepper; 4PIN
P4: Slide; 2PIN
POT1: CONN_1; 1PIN
Q1, Q2: IRML2502; SOT-23_Handsoldering
R1, R2: 1k; R_0805_2012Metric_Pad1.15x1.50mm_HandSolder
R3: 0.33R; R_2512_6332Metric_Pad1.34x3.40mm_HandSolder
R4, R5, R11: 10k; R_0805_2012Metric_Pad1.15x1.50mm_HandSolder
R8: 510; R_0805_2012Metric_Pad1.15x1.50mm_HandSolder
U1: STM8S105K4T6C; LQFP-32_7x7mm_P0.8mm
UP1: CONN_1; 1PIN
VT1: S8205A; TSSOP-8_4.4x3mm_P0.65mm

Connections:
+5V: +5V1.1, C2.1, DA1.2 (VCC), DA1.3 (VCC), DA2.2 (VCC), DA2.3 (VCC), DA3.2 (VCC), DA3.3 (VCC), J1.1, K1.2 (PM), R11.2, U1.6, U1.7, U1.9
+12V: K1.3, P1.1
/NRST: C4.1, J2.1, R11.1, U1.1
/OSC1IN: Q1.1, R4.2, U1.2
/OSC2IN: Q2.1, R5.2, U1.3
/PB0: DA1.6 (IA), U1.16
/PB1: DA1.7 (IB), U1.15
/PB2: DA2.6 (IA), U1.14
/PB3: DA2.7 (IB), U1.13
/PB4: POT1.1, U1.12
/PB5: C3.1, U1.5, U1.11
/PC1: R1.1, U1.18
/PC2: DOWN1.1, U1.19
/PC3: U1.20, UP1.1
/PC4: BTN1.1, U1.21
/PC5: BTN2.1, U1.22
/PD0: P2.1, U1.25
/PD2: DA3.7 (IB), U1.27
/PD3: DA3.6 (IA), U1.28
/PD4: INPUT0.1, U1.29
/PD5: J1.2, U1.30
/PD6: J1.3, U1.31
/PD7: INPUT1.1, U1.32
/PE5: R8.2, U1.17
/PF4: C1.1, R2.1, U1.8
/SWIM/PD1: J2.2, U1.26
GND: C1.2, C2.2, C3.2, C4.2, DA1.5 (GND), DA1.8 (GND), DA2.5 (GND), DA2.8 (GND), DA3.5 (GND), DA3.8 (GND), GND1.1, J1.4, J2.3, K1.1, P2.2 (PM), Q1.2, Q2.2, R3.2, R4.1, R5.1, U1.4, U1.10
unnamed: DA1.1 (OA), P3.2
unnamed: DA1.4 (OB), P3.1
unnamed: DA2.1 (OA), P3.4
unnamed: DA2.4 (OB), P3.3
unnamed: DA3.1 (OA), P4.2 (PM)
unnamed: DA3.4 (OB), P4.1
unnamed: LED0.1, Q1.3
unnamed: LED1.1, Q2.3
unnamed: LED2.1, R8.1
unnamed: P1.2 (PM), VT1.1 (D), VT1.8 (D)
unnamed: R1.2, VT1.4 (G1), VT1.5 (G2)
unnamed: R2.2, R3.1, VT1.2 (S1), VT1.3 (S1), VT1.6 (S2), VT1.7 (S2)

Notes on the sheet:
Stepper motor module
Drill motor + pedal
"DRILLSW" is foot-switch. Press it to move drill down, release to return it to start position. Double-click turns drill motor on/off.
Two buttons on tray have following functionality: BTN1 - setup zero point (move slowly + set coordinate to 0 after footswitch released); next pressing returns device to normal state; BTN2 - switch between regulation of drill speed/stepper speed; BTN1+BTN2 (simultaneously) - move tray up/down. "volu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
Drill PWM
Drill sense
Drill SW
Stepper phases
Tray bridge
BTN1
BTN2
Rvar
Tray Down
Tray Up
All MCU inputs connected to switches should be in "pull-up input" mode.
UART
Tray
Power input
Vcap
+5V Tx Rx gnd
SWIM / debug USART
LED0
LED1
LED2
INPUT1
LEDS 0..3
LEDs 0 and 1 - light 2..3 - indicators
Inputs
INPUT0

Board: 2 copper layers, 53.5 x 50.0 mm, 37 parts (21 on the bottom side), 39 nets.

## KiCad design 220controlled_socket/kicad/socket.kicad_pcb

Parts:
C1, C2, C4, C6, C7, C8, C9, C10, C11, C13: 0.1; C_0603_1608Metric_Pad0.84x1.00mm_HandSolder
C3, C5: 22p; C_0603_1608Metric_Pad0.84x1.00mm_HandSolder
C12: 1n; C_0603_1608Metric_Pad0.84x1.00mm_HandSolder
C14, C15: 0.01 600V; C_Disc_D6.0mm_W2.5mm_P5.00mm
D1: SMF05; SOT-353_SC-70-5_Handsoldering
D2: SS14; D_SMA-SMB_Universal_Handsoldering
D3, D4: BT137-600E; TO-220-3_Vertical
D5: 5V suppressor; D_SOD-323_HandSoldering
D7, D8: SS14; D_SMA
J1: DB9_Female; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
J2: USB_B; USB_B_Horizontal
J3: 5Vext; PinHeader_1x02_P2.54mm_Vertical
J4: SWIM; PinHeader_1x03_P2.54mm_Vertical
J5: DB15_Male; DSUB-15_Male_EdgeMount_P2.77mm
J6, J7: Power; TerminalBlock_Altech_AK300-3_P5.00mm
K1, K2: SRD-05VDC; Relay_SPDT_SANYOU_SRD_Series_Form_C
Q1, Q2, Q5, Q7, Q8, Q9: 2N7002; SOT-23_Handsoldering
Q3, Q4: SI2300; SOT-23_Handsoldering
Q6: AO3407; SOT-23_Handsoldering
R1, R2: 22; R_0603_1608Metric_Pad0.84x1.00mm_HandSolder
R3, R4, R11, R12, R14, R16, R18, R28, R31: 330; R_0603_1608Metric_Pad0.84x1.00mm_HandSolder
R5, R23, R24: 4k7; R_0603_1608Metric_Pad0.84x1.00mm_HandSolder
R6, R13, R25, R26, R27, R29, R30, R32, R33: 47k; R_0805_2012Metric_Pad1.15x1.50mm_HandSolder
R7, R8, R9, R10, R15, R17: 150; R_0603_1608Metric_Pad0.84x1.00mm_HandSolder
R19, R20, R21, R22: 330; R_1206_HandSoldering
R34, R35: 330 2W; R_Axial_Power_L20.0mm_W6.4mm_P25.40mm
U1: MAX3232; SOP-16_4.4x10.4mm_P1.27mm
U2: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U3: STM8S003F3P; SSOP-20_4.4x6.5mm_P0.65mm
U5, U6, U7: PC817; DIP-4_W7.62mm
U8, U9: MOC3063M; DIP-6_W7.62mm
U10: ACS712; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 12M; Crystal_HC49-U_Vertical

Connections:
/Cur0: R5.1, U10.7
/NC1: J6.2, K1.4
/NC2: J7.2, K2.4
/NKEY1: R12.2, U3.15 (PC5_T2C1)
/NKEY2: R11.2, U3.13 (PC3_T1C3)
/NRST: C8.1, J4.2, U3.4 (NRST)
/Out0: R3.2, U3.10 (PA3_T2C3)
/Out1: R4.2, U3.6 (PA2)
/PKEY1: R14.2, R27.1, U3.11 (PB5)
/RXD: D1.3 (K), J1.2, U1.14 (T1OUT)
/Relay0: R16.2, U3.17 (PC7_T1C2)
/Relay1: R18.2, U3.14 (PC4)
/Rx: D7.2 (A), D8.2 (A), R23.2, U3.3 (PD6)
/SWIM: J4.3, U3.18 (PD1)
/TXD: D1.1 (K), J1.3, U1.13 (R1IN)
/Triac0: R28.2, U3.19 (PD2_T2C3)
/Triac1: R31.2, U3.16 (PC6_T1C1)
/Tx: U1.11 (T1IN), U2.3, U3.2 (PD5)
/~In0: D5.1 (K), R9.2, R24.2, U3.12 (PB4)
/~In1: U3.5 (PA1), U5.4
GND: C1.1, C2.1, C3.1, C5.1, C6.1, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, D1.2 (A), D5.2 (A), J1.5, J2.4 (GND), J2.5 (Shield), J3.2, J4.1, J5.6, J5.11 (P111), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), R6.2, R13.1, R25.2, R26.2, R29.1, R30.2, R32.1, R33.2, U1.15 (GND), U2.1, U3.7 (VSS), U5.3, U10.5
unnamed: C1.2, U1.2 (VS+)
unnamed: C2.2, U1.6 (VS-)
unnamed: C3.2, U2.7, Y1.2
unnamed: C4.1, U1.4 (C2+)
unnamed: C4.2, U1.5 (C2-)
unnamed: C5.2, U2.8, Y1.1
unnamed: C6.2, U2.4
unnamed: C7.1, U1.1 (C1+)
unnamed: C7.2, U1.3 (C1-)
unnamed: C9.1, U3.8 (VCAP)
unnamed: C12.1, U10.6
unnamed: C13.1, R5.2, U3.20 (PD3)
unnamed: C14.1, J6.3, U10.3, U10.4
unnamed: C14.2, R34.1
unnamed: C15.1, D4.1, J7.3, K2.3, R21.1
unnamed: C15.2, R35.1
unnamed: D1.4 (K), R2.1, U2.6
unnamed: D1.5 (K), R1.1, U2.5
unnamed: D2.2 (A), J2.1 (VBUS)
unnamed: D3.1, K1.3, R19.1, U10.1, U10.2
unnamed: D3.2, J6.1, K1.1, R20.1, R34.2
unnamed: D3.3, R19.2, U8.4
unnamed: D4.2, J7.1, K2.1, R22.1, R35.2
unnamed: D4.3, R21.2, U9.4
unnamed: D7.1 (K), U2.2
unnamed: D8.1 (K), U1.12 (R1OUT)
unnamed: J2.2 (D-), R2.2
unnamed: J2.3 (D+), R1.2
unnamed: J5.1, U7.4
unnamed: J5.2, U7.3
unnamed: J5.3, U6.4
unnamed: J5.4, U6.3
unnamed: J5.7, Q4.3 (D)
unnamed: J5.8, Q3.3 (D)
unnamed: J5.9, R10.1
unnamed: J5.10, U5.1
unnamed: J5.12, R9.1
unnamed: J5.14, Q6.3 (D)
unnamed: J5.15, Q6.2 (S)
unnamed: K1.5, Q8.3 (D)
unnamed: K2.5, Q9.3 (D)
unnamed: Q1.1 (G), R4.1, R6.1
unnamed: Q1.3 (D), U6.2
unnamed: Q2.1 (G), R3.1, R13.2
unnamed: Q2.3 (D), U7.2
unnamed: Q3.1 (G), R11.1, R25.1
unnamed: Q4.1 (G), R12.1, R26.1
unnamed: Q5.1 (G), R28.1, R29.2
unnamed: Q5.3 (D), U8.2
unnamed: Q6.1 (G), R14.1
unnamed: Q7.1 (G), R31.1, R32.2
unnamed: Q7.3 (D), U9.2
unnamed: Q8.1 (G), R16.1, R30.1
unnamed: Q9.1 (G), R18.1, R33.1
unnamed: R7.1, U6.1
unnamed: R8.1, U7.1
unnamed: R10.2, U5.2
unnamed: R15.1, U8.1
unnamed: R17.1, U9.1
unnamed: R20.2, U8.6
unnamed: R22.2, U9.6
VCC: C10.2, C11.1, D2.1 (K), J3.1, K1.2, K2.2, R7.2, R8.2, R15.2, R17.2, R23.1, R24.1, R27.2, U1.16 (VCC), U2.16, U3.9 (VDD), U10.8

Notes on the sheet:
Channel with current measurement
Channel without current measurement
Inout

Board: 2 copper layers, 87.0 x 71.0 mm, 85 parts (40 on the bottom side), 83 nets.

File 220controlled_socket/kicad/socketBOM.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet
1,Unpolarized capacitor,C,C1 C2 C4 C6 C7 C8 C9 C10 C11 C13,0.1,C_0603_1608Metric_Pad0.84x1.00mm_HandSolder,10,
2,Unpolarized capacitor,C,C12,1n,C_0603_1608Metric_Pad0.84x1.00mm_HandSolder,1,
3,Unpolarized capacitor,C,C3 C5,22p,C_0603_1608Metric_Pad0.84x1.00mm_HandSolder,2,
4,triode for alternating current (TRIAC),BT137-600E,D3 D4,BT137-600E,TO-220-3_Vertical,2,
5,Zener Diode,D_Zener,D5,MM3Z3V6,D_SOD-323_HandSoldering,1,https://en.wikipedia.org/wiki/Zener_diode
6,"TVS Diode Array, 5.5V Standoff, 4 Channels, SOT-23-5 package",SP0504BAHT,D1,SMF05,SOT-353_SC-70-5_Handsoldering,1,http://www.littelfuse.com/~/media/files/littelfuse/technical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
7,Schottky diode,D_Schottky,D2 D6,SS14,D_SMA-SMB_Universal_Handsoldering,2,
8,Diode,D,D7 D8,SS14,D_SMA_Handsoldering,2,
9,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02,J3,5Vext,PinHeader_1x02_P2.54mm_Vertical,1,
10,15-pin male D-SUB connector (low-density/2 columns),DB15_Male,J5,DB15_Male,DSUB-15_Male_EdgeMount_P2.77mm,1,
11,"Generic screw terminal, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",Screw_Terminal_01x03,J6 J7,Power,TerminalBlock_Altech_AK300-3_P5.00mm,2,
12,"Generic connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x03,J4,SWIM,PinHeader_1x03_P2.54mm_Vertical,1,
13,USB Type B connector,USB_B,J2,USB_B,USB_B_Horizontal,1,
14,"Omron G5LE relay, Miniature Single Pole, SPDT, 10A",G5LE-1,K1 K2,SRD-05VDC,Relay_SPDT_SANYOU_SRD_Series_Form_C,2,http://www.omron.com/ecb/products/pdf/en-g5le.pdf
15,Transistor N-MOSFETwith substrate diode (general),Q_NMOS_GSD,Q1 Q2 Q5 Q7 Q8 Q9,2N7002,SOT-23_Handsoldering,6,
16,Transistor P-MOSFET with substrate diode (general),Q_PMOS_GSD,Q6,AO3407,SOT-23_Handsoldering,1,
17,Transistor N-MOSFETwith substrate diode (general),Q_NMOS_GSD,Q3 Q4,SI2300,SOT-23_Handsoldering,2,
18,Resistor,R,R7 R8 R9 R10 R15 R17,150,R_0603_1608Metric_Pad0.84x1.00mm_HandSolder,6,
19,Resistor,R,R1 R2,22,R_0603_1608Metric_Pad0.84x1.00mm_HandSolder,2,
20,Resistor,R,R3 R4 R11 R12 R14 R16 R18 R28 R31,330,R_0603_1608Metric_Pad0.84x1.00mm_HandSolder,9,
21,Resistor,R,R19 R21,330,R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal,2,
22,Resistor,R,R20 R22,330,R_1206_3216Metric_Pad1.24x1.80mm_HandSolder,2,
23,Resistor,R,R6 R13 R25 R26 R27 R29 R30 R32 R33,47k,R_0805_2012Metric_Pad1.15x1.50mm_HandSolder,9,
24,Resistor,R,R5 R23,4k7,R_0603_1608Metric_Pad0.84x1.00mm_HandSolder,2,
25,,ACS712,U10,ACS712,SOIC-8_3.9x4.9mm_P1.27mm,1,
26,,CH340G,U2,CH340G,SOIC-16_3.9x9.9mm_P1.27mm,1,
27,"Dual RS232 driver/receiver, 5V supply, 120kb/s, 0C-70C",MAX3232,U1,MAX3232,SOP-16_4.4x10.4mm_P1.27mm,1,http://www.ti.com/lit/ds/symlink/max232.pdf
28,"Zero Cross Opto-Triac, Vdrm 250V, Ift 15mA, DIP6",MOC3063M,U8 U9,MOC3063M,DIP-6_W7.62mm,2,http://www.fairchildsemi.com/ds/MO/MOC3031M.pdf
29,,PC817,U5 U6 U7,PC817,DIP-4_W7.62mm,3,
30,,STM8S003F3P-RESCUE-socket,U3,STM8S003F3P,SSOP-20_4.4x6.5mm_P0.65mm,1,
31,Two pin crystal,Crystal,Y1,12M,Crystal_HC49-U_Vertical,1,

Component Groups:,31
Component Count:,80
Fitted Components:,80
Number of PCBs:,1
Total components:,80
Schematic Version:,
Schematic Date:,
BoM Date:, 25  2018 20:37:06
Schematic Source:,/Big/Data/00__Electronics/STM8/220controlled_socket/kicad/socket.sch
KiCad Version:,Eeschema 4.0.7

## KiCad design childbake/kicad/bake.kicad_pcb

Board: 2 copper layers, 35.5 x 20.0 mm, 11 parts (5 on the bottom side), 17 nets.

Parts:
C1: 0.1; C_0603_HandSoldering
J1: power; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J2: USART; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J3: USART_On; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J4: SWIM; TerminalBlock_Pheonix_MPT-2.54mm_4pol
J5: CONN_01X07; TerminalBlock_Pheonix_MPT-2.54mm_7pol
Q1, Q2: SI2305DS; SOT-23_Handsoldering
R1, R2: 220; R_0805_HandSoldering
U1: STM8L101F3P; TSSOP-20_4.4x6.5mm_Pitch0.65mm

Connections:
/B0On: J5.2, U1.14
/B1On: J5.3, U1.15
/Burner0: J5.6, U1.18
/Burner1: J5.7, U1.19
/LED0: J5.4, R1.1
/LED1: J5.5, R2.1
/NRST: J4.3, U1.4
/Rx: J2.2, U1.20
/SWIM: J4.4, Q2.1, U1.3
/Sound: J5.1, Q1.3, Q2.3
/Tx: J2.1, U1.1
GND: C1.2, J1.2, J3.1, J4.1, Q1.2, Q2.2, U1.7
unnamed: J3.2, U1.2
unnamed: Q1.1, U1.13
unnamed: R1.2, U1.16
unnamed: R2.2, U1.17
VDD: C1.1, J1.1, J4.2, U1.8

## KiCad design microdrill/schematics/MCU_module.kicad_pcb

Board: 2 copper layers, 47.0 x 34.0 mm, 23 parts (9 on the bottom side), 26 nets.

Parts:
BTN1, BTN2: CONN_1; PINTST
C4, C6: 0.1u; SM0603
C5: 47u; SM1206POL
DA1, DA2, DA3: L9110; so-8
DOWN1: CONN_1; PINTST
DRILL+1: CONN_1; PINTST
DRILL-1: CONN_1; PINTST
DRILLSW1: CONN_1; PINTST
GND1: CONN_1; PINTST
K1: POWER; PIN_ARRAY_3X1
P3: Stepper; PIN_ARRAY_4x1
P4: Slide; PIN_ARRAY_2X1
POT1: CONN_1; PINTST
R4: 47k; SM0603
R5: 0.33R; r_2512
U2: LM1117MPX-3.3; SOT223
UP1: CONN_1; PINTST
VT1: S8205A; TSSOP-8
X1: STM8S105BOARD; devboard_pins-9-14

Connections:
+3.3V: C5.1, U2.2, X1.1
+5V: C4.1, DA1.2, DA1.3, DA2.2, DA2.3, DA3.2, DA3.3, K1.2, U2.3
+12V: DRILL+1.1, K1.3
/Drill motor/DRILL-: DRILL-1.1, VT1.1, VT1.8
/Drill motor/PWM_in: VT1.4, VT1.5, X1.14
/Drill motor/Sence: C6.1, R4.1, X1.6
/PB0: DA1.6, X1.12
/PB1: DA1.7, X1.11
/PB2: DA2.6, X1.10
/PB3: DA2.7, X1.9
/PB4: POT1.1, X1.8
/PC3: DOWN1.1, X1.16
/PC4: UP1.1, X1.17
/PC5: DRILLSW1.1, X1.18
/PC6: BTN1.1, X1.19
/PC7: BTN2.1, X1.20
/PD2: DA3.6, X1.23
/PD3: DA3.7, X1.24
GND: C4.2, C5.2, C6.2, DA1.5, DA1.8, DA2.5, DA2.8, DA3.5, DA3.8, GND1.1, K1.1, R5.2, U2.1, X1.2
unnamed: DA1.1, P3.2
unnamed: DA1.4, P3.1
unnamed: DA2.1, P3.4
unnamed: DA2.4, P3.3
unnamed: DA3.1, P4.1
unnamed: DA3.4, P4.2
unnamed: R4.2, R5.1, VT1.2, VT1.3, VT1.6, VT1.7
