# Repository eddyem/STM8_samples (continued)

## KiCad design DRUM/schematics/drum.kicad_pcb

Board: 2 copper layers, 57.0 x 34.0 mm, 36 parts (5 on the bottom side), 45 nets.

Parts:
C3, C4: 100u; CP_5x11mm
DA1: TDA2822; DIP-8__300
DD1: CD74HC154; DIP-24__300
P7: CONN_10; SIL-10
P8, P9, P10, P11, P12, P13, P15, P16, P18, P19, P20, P21, P22, P23, P24, P25, P26, P27, P28, P29: CONN_1; SIL-1
Q1, Q2, Q3, Q4, Q5, Q6: 2N7002; transistors_gaui-SOT23
R1, R2, R4: 10k; SM0603
R3: 3.3k; SM0603
X1: STM8S105BOARD; devboard_pins-9-14

Connections:
/Audio_in: P10.1, R1.1
/DRUM/BUTN0: P29.1, X1.15
/DRUM/BUTN1: P28.1, X1.16
/DRUM/BUTN2: P27.1, X1.17
/DRUM/BUTN3: P26.1, X1.18
/DRUM/DRUM0: P12.1, X1.6
/DRUM/DRUM1: P13.1, X1.7
/DRUM/LED0: DD1.1, P25.1
/DRUM/LED1: DD1.2, P24.1
/DRUM/LED2: DD1.3, P23.1
/DRUM/LED3: DD1.4, P22.1
/DRUM/LED4: DD1.5, P21.1
/DRUM/LED5: DD1.6, P20.1
/DRUM/SPEAKER: C3.2, C4.2, P11.1
/PB0: DD1.23, X1.12
/PB1: DD1.22, X1.11
/PB2: P16.1, X1.10
/PC1: R2.1, X1.14
/PC6: DD1.19, X1.19
/PD0: Q1.1, X1.21
/PD2: Q4.1, X1.23
/PD3: Q5.1, X1.24
/PD4: Q6.1, X1.25
/PD5: P19.1, X1.26
/PD6: P18.1, X1.27
/PE5: DD1.21, X1.13
/Player/BAT+: P15.1, X1.9
/Player/BTN0a: P7.10, Q1.3
/Player/BTN0b: P7.9, Q1.2
/Player/BTN1a: P7.7, Q2.2
/Player/BTN1b: P7.8, Q2.3
/Player/BTN2a: P7.6, Q3.3
/Player/BTN2b: P7.5, Q4.2
/Player/BTN3a: P7.4, Q5.3
/Player/BTN3b: P7.3, Q5.2
/Player/BTN4a: P7.2, Q6.3
/Player/BTN4b: P7.1, Q6.2
/SWIM/PD1: Q2.1, X1.22
GND: DA1.4, DA1.6, DA1.7, DD1.12, DD1.18, DD1.20, P9.1, X1.2
unnamed: Q3.1, Q3.2, Q4.3
unnamed: DA1.8, R2.2, R4.1
unnamed: DA1.5, R1.2, R3.2
unnamed: C3.1, DA1.3, R3.1
unnamed: C4.1, DA1.1, R4.2
VCC: DA1.2, DD1.24, P8.1, X1.1, X1.8

## KiCad design microdrill/schematics/drill.kicad_pcb

Board: 2 copper layers, 30 parts (0 on the bottom side), 19 nets, no tracks yet.

Parts:
C1: 1u; SM1206
C2, C3: 104; SM0603_Capa
C4: 0.1u; SM0603
C5: 47u; SM1206
C6: 47u; SM1206POL
D1, D2: LED; LED-0603
D3: DIODESCH; D4
K1: POWER; PIN_ARRAY_3X1
P1, P5: CONN_14; SIL-14
P2: CONN_4; SIL-4
P3: Stepper; SIL-4
P4: Slide; SIL-2
P6: CONN_5; SIL-5
P7: CONN_2; SIL-2
R1, R2: 1k; SM0603
R3: 10k; SM0603
R4: 47k; SM0603
R5, R6, R7: 1R; R4
SW1: DRILL; 2PIN_6mm
SW2: UP; 2PIN_6mm
SW3: DOWN; 2PIN_6mm
SW4: SW_PUSH; 2PIN_6mm
U1: STM8S105K4T6C; DIP-8__300
U2: LM1117MPX-3.3; SOT223

Connections:
+3.3V: C2.2, C5.1, D1.1, D2.1, P1.1, P2.1, P6.1, R3.1, U1.6, U1.7, U2.2
+5V: C4.1, K1.2, U2.3
+12V: D3.2, K1.3, P7.1
/Drill motor/Sence: C6.1, P1.6, R4.1, U1.8
/NRST: C3.1, P1.3, P2.3, R3.2, SW4.2, U1.1
/OSC1IN: P1.4, U1.2
/OSC2IN: P1.5, U1.3
/PC2: P5.14, R1.2, SW3.2
/PC3: P5.13, SW2.1
/PC4: P5.12, SW1.1
/PD5: P5.3, P6.4
/PD6: P5.2, P6.3
/SWIM/PD1: P2.2, P5.7
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, K1.1, P1.2, P2.4, P6.5, R2.2, R5.2, R6.2, R7.2, SW1.2, SW2.2, SW3.1, SW4.1, U1.4, U2.1
unnamed: C1.2, U1.5
unnamed: D2.2, R2.1
unnamed: D1.2, R1.1
unnamed: R4.2, R5.1, R6.1, R7.1
unnamed: D3.1, P7.2

## KiCad design stepper_independent_bin/schematic/kicad.kicad_pcb

File stepper_independent_bin/README:

This is a simple example of INDEPENDENT management of 3 stepper motors.

You can connect up to 256 devices to common UART line
To work with them use simple protocol: 
	- each byte have 8 bits of data and nineth control bit
	- inactive modules don't read bytes with nineth bit == 0,
		only active module reads them
	- all modules send data with nineth bit == 0
	- to activate module simple send its number with nineth bit == 1
	- you can change module number (value will be stored in flash memory) by command 'N'
		and get its current number with command 'n'

All motors have independent lines DIR and CLK and common line EN.
Motor selection performed by setting to 1 corresponding EN pin.
Communication with MCU realized through simple USB<->TTL converter.
Just connect lines Rx/Tx of converter to Tx/Rx of evaluation boart,
connect together lines GND and +3.3V.
Communication speed: 57600, proto: 8N1
Comminication with MCU don't need special soft: you can even run screen session
or some terminal client like _com_. Another variant is a simple client - client-term.
MCU itself can print to terminal a short help about its protocol, just sent letter 'h'
to it.

You can connect up to 4 (5 for motor 0) end-point switches for each motor.
There's an ability to move till certain EP switches value, also you can move
motors infinitely (for now it realized only for all motors simultaneously).

Board: 2 copper layers, 15 parts (0 on the bottom side), 31 nets, no tracks yet.

Parts:
C1: 1u; SM1206
C2, C3: 104; SM1206
D1, D2: LED; SM1206
J1: DB25; DB25FC
P1, P3: CONN_14; SIL-14
P2: CONN_4; SIL-4
P4: CONN_5; SIL-5
R1, R2: 1k; SM1206
R3: 10k; SM1206
SW1: SW_PUSH; SM2010
U1: STM8S105K4T6C; TQFP32

Connections:
+3.3V: C2.2, D1.1, D2.1, P1.1, P2.1, P4.1, R3.1, U1.6, U1.7, U1.9
/A DIR: J1.9, P1.9, U1.13
/NRST: C3.1, P1.3, P2.3, R3.2, SW1.2, U1.1
/OSC1IN: P1.4, U1.2
/OSC2IN: P1.5, U1.3
/PB0: J1.3, P1.12, U1.16
/PB1: J1.5, P1.11, U1.15
/PB2: J1.7, P1.10, U1.14
/PB4: P1.8, U1.12
/PB5: P1.7, U1.11
/PC1: J1.2, P1.14, U1.18
/PC2: P3.14, R1.2, U1.19
/PC3: P3.13, U1.20
/PC4: P3.12, U1.21
/PC5: P3.11, U1.22
/PC6: P3.10, U1.23
/PC7: P3.9, U1.24
/PD0: P3.8, U1.25
/PD2: J1.6, P3.6, U1.27
/PD3: P3.5, U1.28
/PD4: J1.4, P3.4, U1.29
/PD5: P3.3, P4.4, U1.30
/PD6: P3.2, P4.3, U1.31
/PD7: P3.1, U1.32
/PE5: P1.13, U1.17
/PF4: P1.6, U1.8
/SWIM/PD1: P2.2, P3.7, U1.26
GND: C1.1, C2.1, C3.2, J1.18, J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, P1.2, P2.4, P4.5, R2.2, SW1.1, U1.4, U1.10
unnamed: D2.2, R2.1
unnamed: C1.2, U1.5
unnamed: D1.2, R1.1

## Code that names these connections

File 220controlled_socket/src/hardware.c:

/*
 *                                                                                                  geany_encoding=koi8-r
 * hardware.c
 *
 * Copyright 2018 Edward V. Emelianov <eddy@sao.ru, edward.emelianoff@gmail.com>
 *
 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 2 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program; if not, write to the Free Software
 * Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston,
 * MA 02110-1301, USA.
 *
 */
#include "hardware.h"

/**
 * HW:
 * PA1 - ~IN1   - PULLUP IN, optocouple input, 0 active
 * PA2 - OUT1   - PUSHPULL OUT, optocouple output, 1 active
 * PA3 - OUT0   - PUSHPULL OUT, optocouple output, 1 active
 * PB4 - ~IN0   - PULLUP IN, direct input
 * PB5 - PKEY1  - PUSHPULL OUT, 0 active
 * PC3 - NKEY2  - PUSHPULL OUT, TIM1_CH3, 1 active
 * PC4 - Relay1 - PUSHPULL OUT, turn ON relay 1, 1 active
 * PC5 - NKEY1  - PUSHPULL OUT, TIM2_CH1, 1 active
 * PC6 - Triac1 - PUSHPULL OUT, turn ON triac 1, 1 active
 * PC7 - Relay0 - PUSHPULL OUT, turn ON relay 0, 1 active
 * PD1 - swim   - Not used
 * PD2 - Triac0 - PUSHPULL OUT, turn ON triac 0, 1 active
 * PD3 - Cur0   - AIN, channel 0 current measurement
 * PD4 - NC     - NC
 * PD5 - Tx \ UART
 * PD6 - Rx /
 */

void hw_init(){
    CFG_GCR |= 1; // disable SWIM
    // Configure clocking
    CLK_CKDIVR = 0; // F_HSI = 16MHz, f_CPU = 16MHz
// Timer 4 (8 bit) used as system tick timer
    // prescaler == 128 (2^7), Tfreq = 125kHz
    // period = 1ms, so ARR = 125
    TIM4_PSCR = 7;
    TIM4_ARR = 125;
    // interrupts: update
    TIM4_IER = TIM_IER_UIE;
    // auto-reload + interrupt on overflow + enable
    TIM4_CR1 = TIM_CR1_APRE | TIM_CR1_URS | TIM_CR1_CEN;

    // default state
    RESET_PKEY1();

    // PA: 1 - PU IN, 2,3 - PP OUT
    PA_DDR = GPIO_PIN2 | GPIO_PIN3;
    PA_CR1 = GPIO_PIN1 | GPIO_PIN2 | GPIO_PIN3;
    // PB: 4 - IN with external pullup (have no int. PU), 5 - [true opendrain] OUT with 1 in default state
    PB_DDR = GPIO_PIN5;
    // PC: 3-7 - PP OUT
    PC_DDR = GPIO_PIN3 | GPIO_PIN4 | GPIO_PIN5 | GPIO_PIN6 | GPIO_PIN7;
    PC_CR1 = GPIO_PIN3 | GPIO_PIN4 | GPIO_PIN5 | GPIO_PIN6 | GPIO_PIN7;
    // PD: 2 - PP OUT, 3 - AIN
    PD_DDR = GPIO_PIN2;
    PD_CR1 = GPIO_PIN2;
    // configure ADC
    // select PD3[AIN4] & enable interrupt for EOC
    ADC_CSR = 0x24; // EOCIE = 1; CH[3:0] = 4 - AIN4
    ADC_TDRL = 0x10; // disable Schmitt triger for AIN4
    // right alignment
    ADC_CR2 = 0x08; // don't forget: first read ADC_DRL!
    // f_{ADC} = f/18 & continuous non-buffered conversion & wake it up
    ADC_CR1 = 0x73; // 0x71 - single, 0x73 - continuous
    ADC_CR1 = 0x73; // turn on ADC (this needs second write operation)
}

File microdrill/ports_definition.h:

/*
 * ports_definition.h - definition of ports pins & so on
 *
 * Copyright 2014 Edward V. Emelianov <eddy@sao.ru, edward.emelianoff@gmail.com>
 *
 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 2 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program; if not, write to the Free Software
 * Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston,
 * MA 02110-1301, USA.
 */

#pragma once
#ifndef __PORTS_DEFINITION_H__
#define __PORTS_DEFINITION_H__

#include "stm8s.h"
#include "main.h"
#include "statemachine.h"

/*
 * Stepper Motor type:
 *   MOTOR_TYPE_UNIPOLAR for 5-wires unipolar motors with darlington array as driver
 *   MOTOR_TYPE_BIPOLAR for 4-wires bipolar motor with L9110-like H-bridges
 */
#define MOTOR_TYPE_BIPOLAR
// anti-clash pause (30ms)
#define ANTICLASH_PAUSE     (30)

// macro for using in port constructions like PORT(LED_PORT, ODR) = xx
#define CONCAT(a, b)	a ## _ ## b
#define PORT(a, b)		CONCAT(a , b)

// ADC threshold (in ADU) - 1% error
#define ADC_THRESHOLD     (10)

// signal LED (LED2) - PE5
#define LED_PORT		PE
#define LED_PIN			GPIO_PIN5
// LED0/LED1 (light & so on): PA1/PA2
#define LED01_PORT      PA
#define LED0_PIN        GPIO_PIN1
#define LED1_PIN        GPIO_PIN2
// Tray pins: PD2/PD3
#define TRAY_PORT       PD
#define TRAY_PINS       (GPIO_PIN2|GPIO_PIN3)

// UART2_TX
#define UART_PORT		PD
#define UART_TX_PIN		GPIO_PIN5
#define newline() do{while(!(UART2_SR & UART_SR_TXE)); UART2_DR = '\n';}while(0)

/***** Stepper motor *****/
// Clocking
#define STP_PORT        PB // PB0..3 -- pins A..D of stepper
// amount of steps on all trace
#define FULL_SCALE_STEPS    (180)
// amount of steps to move up (for PCB moving)
#define MOVEUP_STEPS        (30)
// min/max periods in ticks @ 1kHz (1Hz & 250Hz)
#define MAX_STEPPER_PERIOD  (500)
#define MIN_STEPPER_PERIOD  (2)

/* drill motor PC1 - timer 1 PWM output 1; PC5 - footswitch */
// speed (in ADU values of voltage on schunt)
#define MAX_DRILL_CURRENT (50)
#define NORMAL_DRILL_CURRENT (30)
// lowest (starting) speed in percents
#define DRILL_LOWSPEED  (10)
#define DRILL_ON()      do{TIM1_CCR1L = DRILL_LOWSPEED; TIM1_CR1 |= TIM_CR1_CEN; TIM1_BKR |= 0x80; curstate = DRL_ACCEL;}while(0) // turn on drill motor
#define DRILL_OFF()     do{TIM1_BKR &= ~0x80; TIM1_CR1 &= ~TIM_CR1_CEN; curstate = DRL_RELAX;}while(0) // turn it off
#define DRILL_FASTER()  do{if(drill_maxspeed < 100) ++drill_maxspeed;}while(0)
#define DRILL_SLOWER()  do{if(drill_maxspeed > DRILL_LOWSPEED) --drill_maxspeed;}while(0)
// external buttons & switches: PEDAL (PD0), IN0/IN1 (PD4, PD7)
#define FOOTSWITCH      ((PD_IDR & GPIO_PIN0))
#define INPUT0          ((PD_IDR & GPIO_PIN4))
#define INPUT1          ((PD_IDR & GPIO_PIN7))

/* tray motor: PD2, PD3 - rotation direction; PC2/3 - end-switches (bottom/top) */
#define TRAY_TOP_SW     ((PC_IDR & GPIO_PIN3))
#define TRAY_BTM_SW     ((PC_IDR & GPIO_PIN2))
#define TRAYSW_TEST(x)  ((x & (GPIO_PIN2 | GPIO_PIN3)))
#define TRAYSW_PRSD(x)  (((x & (GPIO_PIN2 | GPIO_PIN3)) != (GPIO_PIN2 | GPIO_PIN3)))
#define TRAY_STOP()     do{PD_ODR &= ~0x0C;}while(0)
#define TRAY_UP()       do{if(TRAY_TOP_SW){PD_ODR &= ~0x0C; PD_ODR |= 0x08;}}while(0)
#define TRAY_DOWN()     do{if(TRAY_BTM_SW){PD_ODR &= ~0x0C; PD_ODR |= 0x04;}}while(0)

/* Buttons: PC4 - BTN1 & PC5 - BTN2 */
#define TRAY_BTN1           ((PC_IDR & GPIO_PIN4))
#define TRAY_BTN2           ((PC_IDR & GPIO_PIN5))
#define TRAY_BTN12_TEST(x)  (((x & (GPIO_PIN4 | GPIO_PIN5)) == (GPIO_PIN4 | GPIO_PIN5)))

// EXTI for all tray buttons: PC2..5
#define BTNS0_IDR               PC_IDR
#define BTNS1_IDR               PD_IDR
// PC2-PC5
#define PC_EXTI_MASK            (0x3c)
// PD0,PD4,PD7
#define PD_EXTI_MASK            (0x91)
#define BTNS_EXTI_DISABLE()  do{PC_CR2 = 0; PD_CR2 = 0;}while(0)
#define BTNS_EXTI_ENABLE()   do{PC_CR2 = PC_EXTI_MASK; PD_CR2 = PD_EXTI_MASK;}while(0)
// setup PC/PD EXTI mask & pullup resistors for PC2..5 & PD0,PD4,PD7
#define BTNS_SETUP()         do{EXTI_CR1 = 0xf0; PC_CR1 |= PC_EXTI_MASK; PD_CR1 |= PD_EXTI_MASK;}while(0)

#endif // __PORTS_DEFINITION_H__

/*
 * PORTS:
 * 	DRILL
 * 		PC1 - PWM (TIM1_CH1)
 * 		PF4 - Sence (AIN12)
 * 		PD0 - Pedal switch
 * 	Stepper motor
 * 		PB0, PB1, PB2, PB3 - phases of motor
 * 	Slider (tray) motor
 * 		PD2, PD3 - rotation direction
 * 		PC2 - down end-switch
 * 		PC3 - up end-switch
 * 	On-tray buttons & resistor
 * 		PB4 - variable resistor (AIN4)
 * 		PC4 - BTN1
 * 		PC5 - BTN2
 * 	UART
 * 		PD5 - TX
 * 		PD6 - RX
 * LEDS
 *      PE5 - LED2 (system blink)
 *      PA1 - LED0  \ external 3..9v LEDs through MOSFET
 *      PA2 - LED1  /
 * Extra inputs
 *      PD4 - IN0
 *      PD7 - IN1
 */

## Commit log

2014-03-18 copy
2014-07-07 distancemeter alpha
2014-07-28 Added DRUM schematic
2014-07-29 added stepper management by ULN2003 Darlington's array
2014-08-06 Fixed error in ULN stepper management + added simple work with bipolar steppers by two L9110s H-bridge drivers
2014-08-11 fix LEDs
2014-08-17 Added alpha-version of schematic + beginning of code (drill)
2014-08-19 Testet automatic drill speed management
2014-09-20 modified DRUM schematics
2014-10-20 Modified some code on "frum" and "microdrill"
2014-11-15 added PCB for microdrill
2015-01-31 started voltmeter hacking
2015-02-01 readme
2015-02-04 add LED support for voltmeter
2015-02-16 added 3 & 4 digit voltmeter schematics
2015-02-21 added 4-digit src
2015-04-04 add 1-wire
2015-04-07 fixed some small things in 1-wire
2015-04-19 add buttons for voltmeters
2015-04-21 added 1-wire at 3-digit voltmeter (still buggy)
2015-04-23 fixed bug with 1st thermometer on 1-wire @ 3-digit voltmeter
2015-04-24 fixed bug with 4-digit themperatures
2015-05-19 I2C (not working yet)
2015-05-23 si7005 next iteration (still doesn't work)
2015-05-30 Hooray! SI7005 works!!!
2015-10-01 Added software I2C on timer TIM2
2016-01-19 added uart-SPI interface
2016-01-20 add LCD 5110
2016-04-21 fix error in 1-wire data conversion for DS18B20
2018-01-01 add child's bake schematic & PCB
2018-02-06 Starting of controlled 220V socket development
2018-02-07 220v socket schematic is over
2018-04-27 fix error in U5 connection on 220v socket
2018-06-05 fix bugs in 220v socket schematics
2018-06-10 1st code for "220"
2018-06-17 src of 220 socket almost ready (not veryfied!)
2018-06-25 fix bug in max3232 & ch340 connection
2018-07-03 fix ADC & change protocol in 220v socket
2018-07-03 fix PCB 220v socket
2018-07-04 add schematic pdf & binary file for 220v socket
2019-01-05 partially worked microdrill
2019-12-17 add LEDS_BT
2019-12-25 add LEDS_BT variant for pseudostart (up to 7 channels)
2020-07-06 add readme
